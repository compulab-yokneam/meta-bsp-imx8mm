FILESEXTRAPATHS_prepend := "${THISDIR}/compulab/imx8mm:"

include compulab/imx8mm.inc

COMPATIBLE_MACHINE = "(ucm-imx8m-mini|mcm-imx8m-mini)"
