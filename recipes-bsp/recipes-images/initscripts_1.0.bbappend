
MASKED_SCRIPTS += " \
  umountfs \
  umountnfs \
  single \
  sendsigs \
  halt \
  reboot \
  rc.local \
  save-rtc \
"
