DESCRIPTION = "CompuLab demo image."
LICENSE = "MIT"

export IMAGE_LINK_NAME="${MACHINE}"

require dynamic-layers/qt5-layer/recipes-fsl/images/fsl-image-qt5-validation-imx.bb
