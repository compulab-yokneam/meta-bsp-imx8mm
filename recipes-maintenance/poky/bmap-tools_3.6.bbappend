SRC_URI = "git://github.com/intel/bmap-tools.git;protocol=https;branch=main"
SRC_URI[sha256sum] = "7c6989258ea0441df8ac0c1bd3f1b2440d2e6a956de428644112237492b08bc0"

