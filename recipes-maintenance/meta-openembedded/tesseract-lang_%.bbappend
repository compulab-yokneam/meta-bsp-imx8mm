SRC_URI = "git://github.com/tesseract-ocr/tessdata.git;protocol=https;branch=main"
SRC_URI[sha256sum] = "0564b88c77f7019528282da88f1da301638c6d0b43da88fce85ad46d70605013"
