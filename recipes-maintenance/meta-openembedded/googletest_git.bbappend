SRC_URI = "git://github.com/google/googletest.git;protocol=https;branch=main"
SRC_URI[sha256sum] = "74d4a499cd689dbdffeb2ce055b2e0ab7bc259ad93f10af827dc2a295287543a"
