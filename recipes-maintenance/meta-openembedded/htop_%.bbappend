SRC_URI_remove = "git://github.com/htop-dev/htop.git"
SRC_URI_prepend = " git://github.com/htop-dev/htop.git;protocol=https;branch=main "

