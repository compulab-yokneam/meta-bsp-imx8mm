PACKAGECONFIG:append = " modemmanager ppp "
